FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
PR .= "-matt"

SRC_URI += " file://man-fix.patch"
